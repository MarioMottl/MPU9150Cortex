# Keil uVision project MPU9150.uvprojx, settings and files
target LageSensor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU9150
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sourcefiles
    ./: main.c i2c.c MPU9150.c
  group header
    ./: i2c.h MPU9150.h
software components: CMSIS:CORE 5.0.1, HTL Hollabrunn:Libraries:STDLib 2.0.0, Device:Startup 1.0.0
